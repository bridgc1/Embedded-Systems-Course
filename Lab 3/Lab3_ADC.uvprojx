# Keil uVision project Lab3_ADC.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2DX4StudioW20E1_ADCDemo
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: PLL.h PLL.c SysTick.c Lab3_ADC.c tm4c1294ncpdt.h SysTick.h
software components: CMSIS:CORE 6.1.0, Device:Startup 3.2.3
